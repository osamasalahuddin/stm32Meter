# Keil uVision project LCDTest.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LCDTest
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40XX
  c include: ..\CMSIS\DSP_Lib\Examples\Common\Include;..\CMSIS\Include;..\Device\Include;..\Device\StdPeriph_Driver\inc;..\Device\StdPeriph_Driver\templates;..\tm_stm32f4_dma;..\tm_stm32f4_fonts;..\tm_stm32f4_gpio_2;..\tm_stm32f4_ili9341;..\tm_stm32f4_spi_2;..\tm_stm32f4_spi_dma;..\defines;..\Main
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../Main/: main.c meter.c init.c
    ../Device/Source/: system_stm32f4xx.c
    ../Device/StdPeriph_Driver/templates/: stm32f4xx_it.c
  group TM
    ../tm_stm32f4_dma/: tm_stm32f4_dma.c
    ../tm_stm32f4_fonts/: tm_stm32f4_fonts.c
    ../tm_stm32f4_gpio_2/: tm_stm32f4_gpio.c
    ../tm_stm32f4_ili9341/: tm_stm32f4_ili9341.c
    ../tm_stm32f4_spi_2/: tm_stm32f4_spi.c
    ../tm_stm32f4_spi_dma/: tm_stm32f4_spi_dma.c
  group Std_Periph_Driver
    ../Device/StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group cmsis
    ../Device/: startup_stm32f4xx.s
